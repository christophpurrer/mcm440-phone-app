require recipes/images/base-image.bb

IMAGE_INSTALL +=

